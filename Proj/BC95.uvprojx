# Keil uVision project BC95.uvprojx, settings and files
target BC95 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BC95 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER LITTLE_ENDIAN,STM32F10X_MD
  c include: ..\Hal;..\Net;..\user;..\Protocol\inc;..\Libraries\CMSIS;..\Libraries\;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\cmsis\startup\arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USR
    ../User/: main.c stm32f10x_it.c
  group HAL
    ../Hal/: led.c i2c.c sht20.c usart1.c usart3.c adxl345.c BH1750.c BMP180.c
  group NET
    ../Net/: bc95.c
  group LIBS
    ../Libraries/: fifo.c memb.c ringbuf.c at_cmd.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group Protocol
    ../Protocol/src/: bootstrap.c environment.c memory.c nbiot.c nblist.c node.c observe.c registraction.c socket.c time.c transaction.c utils.c
software components: CMSIS:CORE 5.0.1
